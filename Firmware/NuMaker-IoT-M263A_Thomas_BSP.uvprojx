# Keil uVision project NuMaker-IoT-M263A_Thomas_BSP.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: NuMaker-IoT-M263A_Thomas_BSP
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Library\CMSIS\Include;.\Library\Device\Nuvoton\M261\Include;.\Library\StdDriver\inc;.\ThirdParty\FreeRTOS\Source\include;.\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_V8M;.\ThirdParty\FreeRTOS\Demo\Common\include;.\
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source
    ./: main.c main.h FreeRTOSConfig.h main-task.c main-task.h sensor-task.c sensor-task.h wifi-task.c wifi-task.h lora-task.c lora-task.h
  group Library
    ./Library/StdDriver/src/: clk.c gpio.c uart.c i2c.c timer.c spi.c
  group Drivers
    ./: blemodule.c blemodule.h wifimodule.c wifimodule.h esensor.c esensor.h loramodule.c loramodule.h
  group FreeRTOS
    ./ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_V8M/: port.c
software components: CMSIS:CORE 5.4.0, Device:Startup 0.00.001
